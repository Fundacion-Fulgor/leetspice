v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/code_shown.sym} 0 0 0 0 {name=INTERFACE only_toplevel=true value="
.subckt multifinger_mos d g s b
* Add the required SG13G2 circuit here.
.ends multifinger_mos
"}
