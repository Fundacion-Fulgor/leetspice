v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/code_shown.sym} 0 0 0 0 {name=INTERFACE only_toplevel=true value="
.subckt common_centroid_pair inp inn outp outn tail vss
* Add the required SG13G2 circuit here.
.ends common_centroid_pair
"}
